# IAR project XY101.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F4152 MSP430F4152
  General.GStackSize2: 80
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: Project; Project\Driver; Project\Driver\cc1101
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: lnk430F4152.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    Project/: DataSendRec.c main.c
    Project/Driver/: DigtalClock.c
    ./: lnk430F4152.xcl readme.txt
  group Driver
    Project/Driver/: Battery.c Battery.h Display.c Display.h HAL_FLASH.c IDS2100.c IDS2100.h include.h IRsensor.c IRsensor.h key.c key.h Uart.c
  group Driver/cc1101
    Project/Driver/cc1101/: CC1100-CC2500.c TI_CC_spi.c
    Project/Driver/: CC1101.c
